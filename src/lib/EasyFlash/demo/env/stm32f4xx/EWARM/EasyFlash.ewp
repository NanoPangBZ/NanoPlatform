# IAR project EasyFlash.ewp, settings and files
configuration STM32F405RG (ARM, debug)
  General.OGChipSelectEditMenu: STM32F405RG ST STM32F405RG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F40_41xxx; USE_FULL_ASSERT
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\app\inc; ..\components\rtt_uart; ..\components\others; ..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\RT-Thread-1.2.2\include; ..\RT-Thread-1.2.2\components\drivers\include; ..\RT-Thread-1.2.2\components\drivers\include\drivers; ..\RT-Thread-1.2.2\components\finsh; ..\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\Libraries\CMSIS\Include; ..\components\easyflash\inc; ..\..\..\..\easyflash\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: EasyFlash.bin
  ILINK.IlinkOutputFile: EasyFlash.out
  ILINK.IlinkIcfFile: ..\components\others\stm32f405xG.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group app
    ../app/src/: app.c app_task.c stm32f4xx_it.c user_finsh_cmd.c
    ../app/inc/: rtconfig.h
  group components/easyflash/port
    ../components/easyflash/port/: ef_port.c
  group components/easyflash/src
    ../../../../easyflash/src/: easyflash.c ef_env.c ef_iap.c ef_utils.c
  group components/others
    ../components/others/: bsp.c utils.c
  group components/rtt_uart
    ../components/rtt_uart/: usart.c
  group libs/cmsis
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f40_41xxx.s
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group libs/std_periph_driver
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group rt_thread_1.2.2/drivers
    ../RT-Thread-1.2.2/components/drivers/src/: completion.c dataqueue.c pipe.c portal.c ringbuffer.c wrokqueue.c
    ../RT-Thread-1.2.2/components/drivers/serial/: serial.c
  group rt_thread_1.2.2/finsh
    ../RT-Thread-1.2.2/components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c msh.c msh_cmd.c shell.c symbol.c
  group rt_thread_1.2.2/kernel
    ../RT-Thread-1.2.2/src/: clock.c cpuusage.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c module.c module.h object.c scheduler.c slab.c thread.c timer.c
  group rt_thread_1.2.2/libcpu
    ../RT-Thread-1.2.2/libcpu/arm/cortex-m4/: context_iar.S cpuport.c
